# Keil uVision project FreeRTOS-Demo1.uvproj, settings and files
target FreeRTOS_Demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: FreeRTOS-Demo1 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F4XX HSE_VALUE=8000000 KEIL_ARMCM4F
  c include: ..\src;..\src\FreeRTOS\include;..\src\FreeRTOS\portable\keil\ARM_CM4F;..\Utilities\STM32F4-Discovery;..\Libraries\CMSIS\Include;..\Libraries\Device\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\uIP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c clock-arch.c enc28j60.c Functions.c mcuInit.c alldefines.h Functions.h mytypes.h mytypes.c rotationTasks.c
    ./: BagsLog.txt
  group FreeRTOS
    ../src/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../src/FreeRTOS/portable/keil/ARM_CM4F/: port.c
    ../src/FreeRTOS/portable/MemMang/: heap_2.c
  group StdPeriph Drivers
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4
    ../src/: stm32f4xx_it.c system_stm32f4xx.c
    ./: startup_stm32f4xx.s
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4_discovery.c
  group uIP
    ../uIP/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c
